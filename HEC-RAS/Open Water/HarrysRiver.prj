HEC-RAS study HarrysRiver.prj: Harry's River

--- HarrysRiver.g02 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,1013.096,150.97,150.97,150.97
XS GIS Cut Line= 3
  397779.7169151 5379264.4225864  397745.4888802 5379421.0158405
  397779.7169151 5379774.4202919
#Sta/Elev= 30
       0   24.52    3.98   23.66   15.93   22.57   30.86   21.89    45.8   19.83
   51.77   18.33   82.63   18.92   92.59   18.85  100.55   18.11  117.48   19.59
  139.38   19.11  161.29   19.87  192.21   19.43  206.17   19.87  218.14   18.78
  257.03   19.96  275.98   19.65  300.92   20.05  303.91   19.66316.3766  17.815
339.1816  17.325373.4651  18.112  388.68   20.13  422.59   19.16  428.58   20.03
  480.44   19.35  482.43   19.74  489.42   23.15   495.4   24.49  515.35   25.48
#Mann= 3 , 0 , 0
       0     .04       0  303.91     .04       0  388.68     .04       0
#XS Ineff= 2 , 0
          301.32   21.98   389.6           22.09
Permanent Ineff=
       F       F
Bank Sta=303.91,388.68
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,862.1243,98.14,98.14,98.14
XS GIS Cut Line= 2
  397748.0559826 5379243.8857651  397557.2346935 5379746.1821632
#Sta/Elev= 30
       0   30.18    5.99   28.04   12.98   27.28   28.96   23.52   43.94   21.91
   55.93   18.21    75.9   18.94   87.89   18.06  102.87   18.91  109.86   18.24
  126.84   18.43  152.81    19.6  195.75    19.1  200.75   18.43  230.71   19.44
  330.58   18.99  344.32   17.66375.5589   16.79394.7545  17.234  412.48   20.31
  430.46   19.17  447.44   18.78  461.42   19.27   474.4   18.58  482.39   19.07
  489.38   22.75  492.38   23.57  508.36   24.71  534.33   24.66  537.32   24.02
#Mann= 3 , 0 , 0
       0     .04       0  330.58     .04       0  412.48     .04       0
#XS Ineff= 2 , 0
          319.82   20.42  414.98           21.66
Permanent Ineff=
       F       F
Bank Sta=330.58,412.48
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,763.9816,209.72,209.72,209.72
XS GIS Cut Line= 2
  397736.0761719 5379240.4629631  397433.1580715 5379692.2730103
#Sta/Elev= 30
       0   30.19       7    30.1      27   28.37      43   23.98      48   21.59
      52   18.35      53   18.25   75.99    17.9   83.99   18.32   87.99   17.69
   99.99   18.91  163.99   18.97  171.99   17.19  180.99   18.65  200.98   18.48
  227.98   19.35  306.98   18.49  338.98   18.77  346.97   17.49381.9675  16.609
  421.97    18.4  435.97   17.61  441.97   18.61  445.97    18.6  458.97   23.09
  481.97    24.1  491.97   23.03  503.97   23.41  518.96   22.95  543.96      24
#Mann= 3 , 0 , 0
       0     .04       0  338.98     .04       0  421.97     .04       0
Levee=-1,327.22,19.02,-1,424.49,18.4,Levee 14,Levee 15
#XS Ineff= 2 , 0
          226.78   22.31
Permanent Ineff=
       F       F
Bank Sta=338.98,421.97
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,554.265 ,178.58,178.58,178.58
XS GIS Cut Line= 2
  397692.4354286 5379235.3287563  397285.1218243 5379459.5223789
#Sta/Elev= 30
       0    31.7      10   31.48      16   32.03      20   31.58      28   26.68
   38.99   18.01   44.99   17.19   50.99   17.26   68.99   18.99   95.99   18.67
  100.99   17.58  105.99   17.34  109.99   18.01  159.98   18.92  186.97    18.6
  196.97   17.86  230.97   19.13  240.97   18.35  262.96      18  275.96   18.47
  285.96   17.93  301.96   18.23  306.96   17.65341.7309  16.653 372.867  16.445
384.9919  17.077386.9826  17.806  389.95   21.26  420.94   22.05  464.94   22.26
#Mann= 3 , 0 , 0
       0     .04       0  301.96     .04       0  389.95     .04       0
Levee=-1,300.44,18.44,0,,,Levee 14,
#XS Ineff= 2 , 0
          230.84   21.72
Permanent Ineff=
       F       F
Bank Sta=301.96,389.95
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,375.6874,136.8,136.8,136.8
XS GIS Cut Line= 3
  397391.2287292 5379127.5104504  397256.8836956 5379308.0633297
  397230.3569698 5379445.8311653
#Sta/Elev= 30
       0    33.2   12.95   32.48   16.93   31.77   37.84   19.03   42.82   16.21
   45.81   15.98   48.79   16.11   52.78   17.08   59.75    17.8   88.63   17.52
   93.61   17.12  100.58   17.33126.7612  16.098150.4068  15.952177.9268  16.337
  198.16   17.87  225.05    17.3  230.03   17.72  245.95   17.08  253.91   18.55
  259.88   18.06  286.74   17.71  306.64   17.89  319.58    17.3  322.56   17.77
  329.53   20.23  332.51   20.62  342.46   20.78   355.4    21.8  365.35   21.86
#Mann= 3 , 0 , 0
       0     .04       0   37.84     .04       0  253.91     .04       0
Levee=0,,,-1,198.06,17.94,,Levee 16
#XS Ineff= 2 , 0
           59.91   20.97   254.1           21.27
Permanent Ineff=
       F       F
Bank Sta=37.84,253.91
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,238.8914,74.99,74.99,74.99
XS GIS Cut Line= 2
  397159.3337994  5379103.550827   397223.511364 5379432.1399517
#Sta/Elev= 30
       0   30.15    9.99   30.46   23.99   30.36   28.98   30.78   33.98    30.1
   38.98   30.91   56.97   31.46   57.97   31.34   61.96   29.19   69.21   23.39
78.82943   17.18 82.1567  16.17586.47436  15.60197.57957  14.921108.8983  14.806
147.6485  17.463   159.9   17.02   165.9   17.14  173.89   16.63  191.88   17.52
  211.87   17.06  231.86   17.28  235.86   16.97  273.83   17.74  301.82   17.83
  306.81   17.25  312.81   17.76  316.81   19.66  318.81   20.17   334.8   21.23
#Mann= 3 , 0 , 0
       0     .04       0   69.21     .04       0  191.88     .04       0
Levee=0,,,-1,148.33,17.45,,Levee 16
#XS Ineff= 2 , 0
                          192.73           20.73
Permanent Ineff=
       F       F
Bank Sta=69.21,191.88
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,163.8985,135.43,135.43,135.43
XS GIS Cut Line= 2
  397056.6496983 5379116.3863392   397207.253046 5379439.8412609
#Sta/Elev= 30
       0    32.6   51.97   32.49   60.97   31.68   72.96   31.77   73.96   31.63
   74.96   30.97   78.96   27.05   85.72   21.89   90.95   18.4296.27667  16.594
101.3584  15.818113.7503   15.18133.1293  14.955149.9247  15.776166.6346  16.052
   184.9   17.12  238.86   16.75  244.86   15.99  247.86   16.34  265.85   16.67
  273.84   17.89  299.83   17.36  322.82   17.57  328.81   17.29  330.81   17.67
  333.81   20.04  334.81   20.23  337.81   20.52   351.8   20.71   356.8   21.15
#Mann= 3 , 0 , 0
       0     .04       0   85.72     .04       0  273.84     .04       0
Levee=0,,,-1,184.67,17.14,,Levee 16
#XS Ineff= 2 , 0
                          272.42           22.06
Permanent Ineff=
       F       F
Bank Sta=85.72,273.84
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,28.46534,28.47,28.47,28.47
XS GIS Cut Line= 3
  396913.7476559 5379086.4368095  396912.0362549 5379233.6173554
  397143.0754833 5379428.7171497
#Sta/Elev= 30
       0   32.68    7.96   32.68    17.9   29.59   37.79   20.63   44.75   16.77
   47.74   16.01    54.7   16.25   60.67   15.73   79.56   16.48   92.49   15.97
   108.4   16.88  123.32   16.86  132.27   16.57  136.25   15.11  175.13   14.93
  210.84 16.0378  216.05   15.69  226.03   16.32250.9319  14.934286.3731  15.093
315.9172  15.688  330.82   16.77   341.8   16.63  347.79   15.85  354.78   16.66
  383.72   17.13  415.66      16  430.63    17.5  439.61   16.94  449.59   17.55
#Mann= 3 , 0 , 0
       0     .04       0  210.84     .04       0  330.82     .04       0
Levee=0,,,-1,331.28,16.8,,Levee 16
#XS Ineff= 2 , 0
          225.55   19.68   381.5           19.92
Permanent Ineff=
       F       F
Bank Sta=210.84,330.82
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Chan Stop Cuts=-1
Use User Specified Reach Order=0
Composite Channel Slope=5
